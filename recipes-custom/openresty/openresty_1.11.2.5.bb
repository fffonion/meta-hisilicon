require openresty.inc

# 1.9.x is the current mainline branches containing all new features
# 1.8.x branch is the current stable branch, the recommended default
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=0bb58ed0dfd4f5dbece3b52aba79f023"

SRC_URI[md5sum] = "bf796f06c07660fa7c7fdcd2d7cc6955"
SRC_URI[sha256sum] = "f8cc203e8c0fcd69676f65506a3417097fc445f57820aa8e92d7888d8ad657b9"

DISABLE_STATIC = ""
