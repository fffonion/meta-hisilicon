require openresty.inc

# 1.9.x is the current mainline branches containing all new features
# 1.8.x branch is the current stable branch, the recommended default
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=0bb58ed0dfd4f5dbece3b52aba79f023"

SRC_URI[md5sum] = "f4b9aa960e57ca692c4d3da731b7e38b"
SRC_URI[sha256sum] = "7f9ca62cfa1e4aedf29df9169aed0395fd1b90de254139996e554367db4d5a01"

DISABLE_STATIC = ""
