require openresty.inc

# 1.9.x is the current mainline branches containing all new features
# 1.8.x branch is the current stable branch, the recommended default
DEFAULT_PREFERENCE = "-1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=0bb58ed0dfd4f5dbece3b52aba79f023"

SRC_URI[md5sum] = "637f82d0b36c74aec1c01bd3b8e0289c"
SRC_URI[sha256sum] = "d1246e6cfa81098eea56fb88693e980d3e6b8752afae686fab271519b81d696b"

DISABLE_STATIC = ""
